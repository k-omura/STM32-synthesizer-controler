/**
 * @file app_dispatcher.c
 * @author k-omura
 * @brief
 * @version 0.1
 * @date 2026-06-22
 *
 */

#include "app_dispatcher.h"

#include "app_transition.h"
#include "domain_mode_def.h"

/**
 * @brief Handles an incoming event by dispatching it to the appropriate mode handler based on the current runtime context. This function retrieves the current mode definition and calls its `on_event` handler if it exists. After processing the event, it resolves any potential mode or node transitions that may have been triggered by the event.
 *
 * @param ctx The current runtime context containing mode and node information.
 * @param ev The event to be handled.
 * @param out_cmds An output buffer for commands generated by the event handler.
 * @param out_count An output variable to store the number of commands generated.
 */
void app_dispatcher_handle_event(const app_runtime_context_t *ctx, const app_event_t *ev, app_command_t *out_cmds, uint8_t *out_count)
{
    app_mode_state_t next_mode;
    uint16_t next_node;
    const domain_mode_def_t *mode_def;
    const domain_mode_def_t *current_mode_def;
    const domain_mode_def_t *next_mode_def;

    if ((ctx == 0) || (ev == 0) || (out_cmds == 0) || (out_count == 0))
    {
        return;
    }

    *out_count = 0;

    next_mode = ctx->current_mode;
    next_node = ctx->current_node;

    mode_def = domain_mode_def_get(ctx->current_mode);

    if (mode_def != 0 && mode_def->on_event != 0)
    {
        mode_def->on_event((void *)ctx, ev, out_cmds, out_count);
    }

    app_transition_resolve(ctx, ev, &next_mode, &next_node);

    if ((next_mode != ctx->current_mode) && (*out_count < APP_COMMAND_BUFFER_CAPACITY))
    {
        current_mode_def = domain_mode_def_get(ctx->current_mode);
        if ((current_mode_def != 0) && (current_mode_def->on_exit != 0))
        {
            current_mode_def->on_exit((void *)ctx, ev, out_cmds, out_count);
        }

        if (*out_count < APP_COMMAND_BUFFER_CAPACITY)
        {
            out_cmds[*out_count].type = CMD_MODE_CHANGE;
            out_cmds[*out_count].payload.mode = next_mode;
            (*out_count)++;
        }

        next_mode_def = domain_mode_def_get(next_mode);
        if ((next_mode_def != 0) && (next_mode_def->on_enter != 0))
        {
            next_mode_def->on_enter((void *)ctx, ev, out_cmds, out_count);
        }
    }

    if ((next_node != ctx->current_node) && (*out_count < APP_COMMAND_BUFFER_CAPACITY))
    {
        out_cmds[*out_count].type = CMD_NODE_CHANGE;
        out_cmds[*out_count].payload.node = next_node;
        (*out_count)++;
    }
}

/**
 * @brief Handles a tick event by calling the `on_tick` handler of the current mode definition, if it exists. This function is typically called on each timer tick to allow modes to perform time-based updates or actions.
 *
 * @param ctx The current runtime context containing mode and node information.
 * @param now_tick The current tick count, which can be used for timing purposes within the mode handlers.
 * @param out_cmds An output buffer for commands generated by the tick handler.
 * @param out_count An output variable to store the number of commands generated.
 */
void app_dispatcher_handle_tick(const app_runtime_context_t *ctx, uint32_t now_tick, app_command_t *out_cmds, uint8_t *out_count)
{
    const domain_mode_def_t *mode_def;

    (void)now_tick;

    if ((ctx == 0) || (out_cmds == 0) || (out_count == 0))
    {
        return;
    }

    *out_count = 0;

    mode_def = domain_mode_def_get(ctx->current_mode);

    if (mode_def != 0 && mode_def->on_tick != 0)
    {
        mode_def->on_tick((void *)ctx, (const app_event_t *)0, out_cmds, out_count);
    }
}
